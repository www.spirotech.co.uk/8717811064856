Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2025-07-24T15:52:04+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M1_INT-EN:EMCM-M1-8.1-twin, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M1_INT-EN:EMCM-M1-8.1-twin:183927
In: Level 1
Type - Material: Color RGB 040-040-040, Color RGB 200-200-200, Color RGB 250-000-000, Color RGB 181-166-066, Color RAL 1003, Color RGB 115-115-115, Color RGB 255-255-255, Color RGB 055-055-055
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 746.5 mm; Height: 1148.5 mm; Hydronic Diameter: 25.4 mm; Overflow Diameter: 25.4 mm; Refill Diameter: 12.7 mm; Suction Diameter: 25.4 mm; Use Nominal Diameter: yes; Width: 866 mm
Type - Electrical - Loads - Power: 1500 W
Type - Electrical Engineering - Voltage: 230 V
Type - Identity Data - Article Description: SpiroExpand MultiControl Modular Maxi Twin; Article Type: EMCM-M1-8.1-twin; Base Family Version: 25.08; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: SpiroExpand MultiControl Modular Maxi Twin; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 25.08; GLN: 8717811000007; GTIN: 8717811064856; Manufacturer: Spirotech; Manufacturer Art. No.: EMCM-M1-8.1-twin; Manufacturer URL: https://www.eder-spirotech.at/produkte/expansionsautomaten/multicontrol-modular-maxi-twin-272?variant=2016; MEPcontent Class: VACUUM_DEGASSER; Model: EMCM-M1-8.1-twin; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: EMCM-M1-8.1-twin; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-100-200; Dark Grey: Color RGB 115-115-115; Light Black: Color RGB 055-055-055; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Other - Category: Mechanical Equipment; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M1_INT-EN; Flow In Length: 327 mm; Flow Out Length: 440 mm; Total Width: 465 mm
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EMCM-M1-8.1-twin
Pset_EnvironmentalImpactIndicators - Reference: EMCM-M1-8.1-twin
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 9.41803 m2; Volume: 0.21899 m3
Identity Data - Mark: 1
Mechanical - Flow In: 0 m3/s; Flow In 2: 0 m3/s; Flow Out: 0 m3/s; Refill Flow: 0 m3/s; Suction Flow: 0 m3/s; System Classification: Undefined,Power
Other - Angle: 0 deg; Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M1_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M1_INT-EN: EMCM-M1-8.1-twin; Front Clearance Safe: 500 mm; Left Clearance Safe: 500 mm; Left Side Pipe: 392 mm; Reference Line Length: 538 mm; Right Clearance Safe: 500 mm; Right Side Pipe: 387 mm; Service Space Plane: 411 mm; Top Clearance Safe: 500 mm; Type: EMCM-M1-8.1-twin; Type Id: 183910
Phasing - Phase Created: New Construction
Visibility - Back Clearance: 0 mm; Front Clearance: 500 mm; Left Clearance: 500 mm; Left Side Connection: no; Right Clearance: 500 mm; Right Side Connection: yes; Show Service Area: no; Top Clearance: 500 mm

# IfcDistributionPort (6)
Description: Flow
Name | FlowDirection | PredefinedType
Port_183927 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
3 x Port_183927 | SINK | PIPE
2 x Port_183927 | SOURCE | PIPE
